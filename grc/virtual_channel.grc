<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gwn_event_sink</key>
<param><key>id</key><value>gwn_event_sink_0</value></param>
<param><key>blkname</key><value></value></param>
<param><key>blkid</key><value></value></param>
</block>
<block>
<key>gwn_ev_to_pdu</key>
<param><key>id</key><value>gwn_ev_to_pdu_0</value></param>
<param><key>blkname</key><value></value></param>
<param><key>blkid</key><value></value></param>
<param><key>in_type</key><value>'event'</value></param>
</block>
<block>
<key>gwn_timer_source</key>
<param><key>id</key><value>gwn_timer_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>blkname</key><value></value></param>
<param><key>blkid</key><value></value></param>
<param><key>interrupt</key><value>False</value></param>
<param><key>interval</key><value>1.0</value></param>
<param><key>retry</key><value>10</value></param>
<param><key>nickname1</key><value>TimerTOR1</value></param>
<param><key>nickname2</key><value>TimerTOR2</value></param>
</block>
<block>
<key>gwn_timer_source</key>
<param><key>id</key><value>gwn_timer_source_1</value></param>
<param><key>blkname</key><value></value></param>
<param><key>blkid</key><value></value></param>
<param><key>interrupt</key><value>False</value></param>
<param><key>interval</key><value>1.0</value></param>
<param><key>retry</key><value>10</value></param>
<param><key>nickname1</key><value>TimerTOR1</value></param>
<param><key>nickname2</key><value>TimerTOR2</value></param>
</block>
<block>
<key>gwn_virtual_channel</key>
<param><key>id</key><value>gwn_virtual_channel_1</value></param>
<param><key>blkname</key><value></value></param>
<param><key>blkid</key><value></value></param>
<param><key>prob_loss</key><value> 0.5</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<connection><source_block_id>gwn_virtual_channel_1</source_block_id><sink_block_id>gwn_event_sink_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_timer_source_0</source_block_id><sink_block_id>gwn_virtual_channel_1</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_timer_source_1</source_block_id><sink_block_id>gwn_ev_to_pdu_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_ev_to_pdu_0</source_block_id><sink_block_id>gwn_virtual_channel_1</sink_block_id><source_key>pdu</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>gwn_virtual_channel_1</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdu</source_key><sink_key>print</sink_key></connection>
</flow_graph>
