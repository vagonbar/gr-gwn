<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>title</key><value>Channel with Events</value></param>
<param><key>description</key><value>Events from source to sink</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>access_code</value></param>
<param><key>value</key><value>gwnutils.default_access_code</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio import digital</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import gwnutils</value></param>
</block>
<block>
<key>digital_correlate_access_code_xx_ts</key>
<param><key>id</key><value>digital_correlate_access_code_xx_ts_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>threshold</key><value>1</value></param>
<param><key>tagname</key><value>correlate</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>correlate</value></param>
</block>
<block>
<key>gwn_ev_psk_decode</key>
<param><key>id</key><value>gwn_ev_psk_decode_0</value></param>
<param><key>blkname</key><value></value></param>
<param><key>blkid</key><value></value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>gwn_event_sink</key>
<param><key>id</key><value>gwn_event_sink_0</value></param>
<param><key>blkname</key><value>Event Sink</value></param>
<param><key>blkid</key><value>evsink1</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<block>
<key>gwn_ev_psk_encode</key>
<param><key>id</key><value>gwn_ev_psk_encode_0</value></param>
<param><key>blkname</key><value></value></param>
<param><key>blkid</key><value></value></param>
<param><key>in_type</key><value>'event'</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>gwn_hier_rx_psk</key>
<param><key>id</key><value>gwn_hier_rx_psk_0</value></param>
<param><key>bw_clock_sync</key><value> 2*3.14/100 </value></param>
<param><key>bw_fll</key><value> 3.14/1600 </value></param>
<param><key>bw_costas</key><value> 2*3.14/100 </value></param>
<param><key>len_sym_srrc</key><value> 7 </value></param>
<param><key>n_filts</key><value> 32 </value></param>
<param><key>constellation</key><value>digital.constellation_calcdist([-1-1j, 1-1j, 1+1j, -1+1j], [], 4, 1).base()</value></param>
<param><key>samp_per_sym</key><value> 5 </value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>bits_per_sym</key><value> 2 </value></param>
<param><key>agc_attack_rate</key><value>0.1</value></param>
<param><key>agc_decay_rate</key><value>0.1</value></param>
<param><key>agc_reference</key><value>1.0</value></param>
<param><key>agc_gain</key><value>1.0</value></param>
<param><key>alpha_probe</key><value>0.1</value></param>
<param><key>th_probe</key><value>0</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>noise_voltage</key><value>0.0</value></param>
<param><key>freq_offset</key><value>0.0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>taps</key><value>1.0</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>gwn_hier_tx_psk</key>
<param><key>id</key><value>gwn_hier_tx_psk_0</value></param>
<param><key>constellation</key><value>[-1-1j, 1-1j, 1+1j, -1+1j]</value></param>
<param><key>samp_per_sym</key><value> 5 </value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>bits_per_sym</key><value> 2 </value></param>
<param><key>len_sym_srrc</key><value> 7 </value></param>
<param><key>out_const_mul</key><value> 0.4 </value></param>
</block>
<block>
<key>gwn_timer_source</key>
<param><key>id</key><value>gwn_timer_source_0</value></param>
<param><key>blkname</key><value></value></param>
<param><key>blkid</key><value></value></param>
<param><key>interrupt</key><value>False</value></param>
<param><key>interval</key><value>2</value></param>
<param><key>retry</key><value>2</value></param>
<param><key>nickname1</key><value>TimerTOR1</value></param>
<param><key>nickname2</key><value>TimerTOR2</value></param>
<param><key>payload</key><value></value></param>
</block>
<block>
<key>gwn_data_source</key>
<param><key>id</key><value>gwn_data_source_0</value></param>
<param><key>blkname</key><value></value></param>
<param><key>blkid</key><value></value></param>
<param><key>interrupt</key><value>False</value></param>
<param><key>interval</key><value>1.0</value></param>
<param><key>retry</key><value>3</value></param>
<param><key>nickname</key><value>'DataData'</value></param>
<param><key>payload</key><value>'a'*40</value></param>
</block>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>gwn_hier_tx_psk_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gwn_hier_tx_psk_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>gwn_hier_rx_psk_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gwn_hier_rx_psk_0</source_block_id><sink_block_id>digital_correlate_access_code_xx_ts_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_xx_ts_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gwn_data_source_0</source_block_id><sink_block_id>gwn_ev_psk_encode_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_ev_psk_encode_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdu</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>gwn_ev_psk_decode_0</sink_block_id><source_key>pdus</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>gwn_ev_psk_decode_0</source_block_id><sink_block_id>gwn_event_sink_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_timer_source_0</source_block_id><sink_block_id>gwn_ev_psk_encode_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
</flow_graph>
