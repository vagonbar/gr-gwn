<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gwn_msg_receiver_m</key>
<param><key>id</key><value>gwn_msg_receiver_m_0</value></param>
<param><key>blkname</key><value>Receiver ONE</value></param>
<param><key>blkid</key><value>blk02</value></param>
</block>
<block>
<key>gwn_msg_receiver_m</key>
<param><key>id</key><value>gwn_msg_receiver_m_1</value></param>
<param><key>blkname</key><value>Receiver TWO</value></param>
<param><key>blkid</key><value>blk03</value></param>
</block>
<block>
<key>gwn_msg_sender_m</key>
<param><key>id</key><value>gwn_msg_sender_m_0</value></param>
<param><key>blkname</key><value>Sender ONE</value></param>
<param><key>blkid</key><value>blk0</value></param>
<param><key>interrupt</key><value>False</value></param>
<param><key>interval</key><value>1</value></param>
<param><key>retry</key><value>10</value></param>
<param><key>nickname1</key><value>TimerTOC</value></param>
<param><key>nickname2</key><value>TimerTOH</value></param>
</block>
<connection><source_block_id>gwn_msg_sender_m_0</source_block_id><sink_block_id>gwn_msg_receiver_m_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_msg_sender_m_0</source_block_id><sink_block_id>gwn_msg_receiver_m_1</sink_block_id><source_key>out1</source_key><sink_key>in0</sink_key></connection>
</flow_graph>
