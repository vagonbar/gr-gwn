<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_probe_medium</value></param>
<param><key>title</key><value>Test Probe Medium</value></param>
<param><key>author</key><value>The GWN team</value></param>
<param><key>description</key><value>Tests Probe medium block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>1024000</value></param>
<param><key>srate</key><value>1000000</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_second</key><value>1000000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>1000000</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>20000</value></param>
<param><key>amp</key><value>cos_ampl</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>gwn_event_sink</key>
<param><key>id</key><value>gwn_event_sink_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>gwn_data_source</key>
<param><key>id</key><value>gwn_data_source_0</value></param>
<param><key>interrupt</key><value>False</value></param>
<param><key>interval</key><value>0.5</value></param>
<param><key>retry</key><value>300</value></param>
<param><key>src_addr</key><value>'00:00:00:00:00:00'</value></param>
<param><key>dst_addr</key><value>'00:00:00:00:00:00'</value></param>
<param><key>ev_dc</key><value>{}</value></param>
<param><key>payload</key><value>'Data to transmit. '</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe_signal</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>cos_ampl</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>probe_signal</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>100</value></param>
</block>
<block>
<key>analog_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>probe_avg_mag_sqrd</value></param>
<param><key>type</key><value>f</value></param>
<param><key>threshold</key><value>0</value></param>
<param><key>alpha</key><value>1</value></param>
</block>
<block>
<key>gwn_probe_medium</key>
<param><key>id</key><value>gwn_probe_medium_0</value></param>
<param><key>transmit_threshold</key><value>0.1</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>block_id</key><value>probe_avg_mag_sqrd</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>function_args</key><value></value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>1000000</value></param>
<param><key>waveform</key><value>analog.GR_SQR_WAVE</value></param>
<param><key>freq</key><value>0.05</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>1000000</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_second</key><value>1000000</value></param>
</block>
<connection><source_block_id>gwn_data_source_0</source_block_id><sink_block_id>gwn_probe_medium_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_probe_medium_0</source_block_id><sink_block_id>gwn_event_sink_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>probe_avg_mag_sqrd</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>probe_signal</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
