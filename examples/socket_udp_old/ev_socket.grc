<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ev_socket</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gwn_data_source</key>
<param><key>id</key><value>gwn_data_source_0</value></param>
<param><key>interrupt</key><value>False</value></param>
<param><key>interval</key><value>1.0</value></param>
<param><key>retry</key><value>10</value></param>
<param><key>src_addr</key><value>'00:00:00:00:00:00'</value></param>
<param><key>dst_addr</key><value>'00:00:00:00:00:00'</value></param>
<param><key>ev_dc</key><value>{}</value></param>
<param><key>payload</key><value>"SERVER payload"</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>gwn_ev_to_pdu</key>
<param><key>id</key><value>gwn_ev_to_pdu_0</value></param>
<param><key>in_type</key><value>'event'</value></param>
</block>
<block>
<key>gwn_pdu_to_ev</key>
<param><key>id</key><value>gwn_pdu_to_ev_0</value></param>
<param><key>in_type</key><value>'event'</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
<param><key>host</key><value>'127.0.0.1'</value></param>
<param><key>port</key><value>50007</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
<param><key>host</key><value>'127.0.0.1'</value></param>
<param><key>port</key><value>50007</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>gwn_event_sink</key>
<param><key>id</key><value>gwn_event_sink_0</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<connection><source_block_id>gwn_ev_to_pdu_0</source_block_id><sink_block_id>blocks_socket_pdu_0_0</sink_block_id><source_key>pdu</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gwn_data_source_0</source_block_id><sink_block_id>gwn_ev_to_pdu_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_pdu_to_ev_0</source_block_id><sink_block_id>gwn_event_sink_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>gwn_pdu_to_ev_0</sink_block_id><source_key>pdus</source_key><sink_key>pdu</sink_key></connection>
</flow_graph>
