<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gwn_l2_framer</key>
<param><key>id</key><value>gwn_l2_framer_0</value></param>
<param><key>pack</key><value>'event'</value></param>
</block>
<block>
<key>gwn_event_sink</key>
<param><key>id</key><value>gwn_event_sink_0</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<block>
<key>gwn_data_source</key>
<param><key>id</key><value>gwn_data_source_0</value></param>
<param><key>interrupt</key><value>False</value></param>
<param><key>interval</key><value>1.0</value></param>
<param><key>retry</key><value>3</value></param>
<param><key>src_addr</key><value>'01:00:00:00:00:11'</value></param>
<param><key>dst_addr</key><value>'02:00:00:00:00:22'</value></param>
<param><key>ev_dc</key><value>{}</value></param>
<param><key>payload</key><value>'L2 framer test payload'</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>gwn_l2_deframer</key>
<param><key>id</key><value>gwn_l2_deframer_0</value></param>
<param><key>pack</key><value>'event'</value></param>
</block>
<connection><source_block_id>gwn_data_source_0</source_block_id><sink_block_id>gwn_l2_framer_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_l2_framer_0</source_block_id><sink_block_id>gwn_l2_deframer_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_l2_deframer_0</source_block_id><sink_block_id>gwn_event_sink_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
</flow_graph>
