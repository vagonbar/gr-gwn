<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>access_code</value></param>
<param><key>value</key><value>gwnutils.default_access_code</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>prueba</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>noise_voltage</key><value>0.0</value></param>
<param><key>freq_offset</key><value>0.0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>taps</key><value>1.0</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>gwn_hier_tx_psk</key>
<param><key>id</key><value>gwn_hier_tx_psk_0</value></param>
<param><key>constellation</key><value>[-1-1j, 1-1j, 1+1j, -1+1j]</value></param>
<param><key>samp_per_sym</key><value> 5 </value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>bits_per_sym</key><value> 2 </value></param>
<param><key>len_sym_srrc</key><value> 7 </value></param>
<param><key>out_const_mul</key><value> 0.4 </value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>from gnuradio import digital</value></param>
</block>
<block>
<key>gwn_hier_rx_psk</key>
<param><key>id</key><value>gwn_hier_rx_psk_0</value></param>
<param><key>bw_clock_sync</key><value> 2*3.14/100 </value></param>
<param><key>bw_fll</key><value> 3.14/1600 </value></param>
<param><key>bw_costas</key><value> 2*3.14/100 </value></param>
<param><key>len_sym_srrc</key><value> 7 </value></param>
<param><key>n_filts</key><value> 32 </value></param>
<param><key>constellation</key><value>digital.constellation_calcdist([-1-1j, 1-1j, 1+1j, -1+1j], [], 4, 1).base()</value></param>
<param><key>samp_per_sym</key><value> 5 </value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>bits_per_sym</key><value> 2 </value></param>
<param><key>agc_attack_rate</key><value>0.1</value></param>
<param><key>agc_decay_rate</key><value>0.1</value></param>
<param><key>agc_reference</key><value>1.0</value></param>
<param><key>agc_gain</key><value>1.0</value></param>
<param><key>alpha_probe</key><value>0.1</value></param>
<param><key>th_probe</key><value>0</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>(0, 1,2,3,4,5,6,7,8,9)*1</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0_0</value></param>
<param><key>import</key><value>import gwnutils</value></param>
</block>
<block>
<key>digital_correlate_access_code_xx_ts</key>
<param><key>id</key><value>digital_correlate_access_code_xx_ts_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>threshold</key><value>1</value></param>
<param><key>tagname</key><value>prueba</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/belza/Dropbox/proyectos/GruposCSIC/pruebasgnuradio/pkt_encoder1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blks2_packet_encoder</key>
<param><key>id</key><value>blks2_packet_encoder_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_symbol</key><value>5</value></param>
<param><key>bits_per_symbol</key><value>2</value></param>
<param><key>preamble</key><value></value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>pad_for_usrp</key><value>False</value></param>
<param><key>payload_length</key><value>2</value></param>
</block>
<connection><source_block_id>gwn_hier_tx_psk_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>gwn_hier_rx_psk_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_xx_ts_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blks2_packet_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_encoder_0</source_block_id><sink_block_id>gwn_hier_tx_psk_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gwn_hier_rx_psk_0</source_block_id><sink_block_id>blocks_file_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gwn_hier_rx_psk_0</source_block_id><sink_block_id>blocks_char_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gwn_hier_rx_psk_0</source_block_id><sink_block_id>digital_correlate_access_code_xx_ts_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
