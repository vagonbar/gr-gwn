<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>2</value></param>
<param><key>len_tag_key</key><value>"tsb_tag"</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>tsb_tag</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>tsb_tag</value></param>
</block>
<block>
<key>tutorial_my_qpsk_demod_cb</key>
<param><key>id</key><value>tutorial_my_qpsk_demod_cb_0</value></param>
<param><key>gray_code</key><value>True</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_1</value></param>
<param><key>k</key><value>2</value></param>
<param><key>l</key><value>8</value></param>
<param><key>len_tag_key</key><value>"tsb_tag"</value></param>
<param><key>align_output</key><value>True</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>QPSK.points()</value></param>
<param><key>dimension</key><value>1</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>QPSK</value></param>
<param><key>sym_map</key><value>[0, 1, 3, 2]</value></param>
<param><key>const_points</key><value>[1+1j, -1+1j, 1-1j, -1-1j]</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>gwn_event_sink</key>
<param><key>id</key><value>gwn_event_sink_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_1</value></param>
<param><key>check</key><value>True</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_0</value></param>
<param><key>check</key><value>False</value></param>
</block>
<block>
<key>gwn_data_source</key>
<param><key>id</key><value>gwn_data_source_0</value></param>
<param><key>interrupt</key><value>False</value></param>
<param><key>interval</key><value>1.0</value></param>
<param><key>retry</key><value>3</value></param>
<param><key>src_addr</key><value>'00:00:00:00:00:00'</value></param>
<param><key>dst_addr</key><value>'00:00:00:00:00:00'</value></param>
<param><key>ev_dc</key><value>{}</value></param>
<param><key>payload</key><value>''</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>gwn_ieee80211_deframer</key>
<param><key>id</key><value>gwn_ieee80211_deframer_0</value></param>
</block>
<block>
<key>gwn_ieee80211_framer</key>
<param><key>id</key><value>gwn_ieee80211_framer_0</value></param>
</block>
<block>
<key>gwn_timer_source</key>
<param><key>id</key><value>gwn_timer_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>interrupt</key><value>False</value></param>
<param><key>interval</key><value>1.0</value></param>
<param><key>retry</key><value>3</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>ev_dc_1</key><value>{}</value></param>
<param><key>ev_dc_2</key><value>{}</value></param>
</block>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_1</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>digital_crc32_async_bb_1</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>tutorial_my_qpsk_demod_cb_0</source_block_id><sink_block_id>blocks_repack_bits_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>tutorial_my_qpsk_demod_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gwn_timer_source_0</source_block_id><sink_block_id>gwn_ieee80211_framer_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_ieee80211_deframer_0</source_block_id><sink_block_id>gwn_event_sink_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_1</source_block_id><sink_block_id>gwn_ieee80211_deframer_0</sink_block_id><source_key>out</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>gwn_ieee80211_framer_0</source_block_id><sink_block_id>digital_crc32_async_bb_0</sink_block_id><source_key>pdu</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>gwn_data_source_0</source_block_id><sink_block_id>gwn_ieee80211_framer_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
</flow_graph>
