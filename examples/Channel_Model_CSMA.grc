<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>CSMA_completa</value></param>
<param><key>author</key><value>Extranjero</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>access_code</value></param>
<param><key>value</key><value>gwnutils.default_access_code</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>debug_rx</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>analog_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>analog_probe_avg_mag_sqrd_x_0</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>threshold</key><value>-10</value></param>
<param><key>type</key><value>c</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>0.2</value></param>
<param><key>freq</key><value>100000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SQR_WAVE</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_1</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>50007</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_1_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>50008</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>gwn_CSMA_FSM</key>
<param><key>id</key><value>gwn_CSMA_FSM_0</value></param>
<param><key>ack_nickname</key><value>'CtrlACK'</value></param>
<param><key>block_id</key><value>analog_probe_avg_mag_sqrd_x_0</value></param>
<param><key>buffer_len</key><value>1000</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>fsm_debug</key><value>False</value></param>
<param><key>function_args</key><value></value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>max_retries</key><value>1000</value></param>
<param><key>tout_backoff</key><value>'TimerTOH'</value></param>
<param><key>timeout_backoff</key><value>.01</value></param>
<param><key>tout_nickname</key><value>'EventTimer'</value></param>
<param><key>timeout</key><value>0.1</value></param>
<param><key>transmit_threshold</key><value>0.7</value></param>
</block>
<block>
<key>gwn_CSMA_FSM</key>
<param><key>id</key><value>gwn_CSMA_FSM_0_0</value></param>
<param><key>ack_nickname</key><value>'CtrlACK'</value></param>
<param><key>block_id</key><value>analog_probe_avg_mag_sqrd_x_0</value></param>
<param><key>buffer_len</key><value>1000</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>fsm_debug</key><value>False</value></param>
<param><key>function_args</key><value></value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>max_retries</key><value>60</value></param>
<param><key>tout_backoff</key><value>'TimerTOH'</value></param>
<param><key>timeout_backoff</key><value>.1</value></param>
<param><key>tout_nickname</key><value>'EventTimer'</value></param>
<param><key>timeout</key><value>1</value></param>
<param><key>transmit_threshold</key><value>0.7</value></param>
</block>
<block>
<key>gwn_ack_rx</key>
<param><key>id</key><value>gwn_ack_rx_0</value></param>
<param><key>ack_nickname</key><value>'CtrlACK'</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<block>
<key>gwn_ack_rx</key>
<param><key>id</key><value>gwn_ack_rx_0_0</value></param>
<param><key>ack_nickname</key><value>'CtrlACK'</value></param>
<param><key>debug</key><value>debug_rx</value></param>
</block>
<block>
<key>gwn_ev_to_pdu</key>
<param><key>id</key><value>gwn_ev_to_pdu_0</value></param>
<param><key>in_type</key><value>'payload'</value></param>
</block>
<block>
<key>gwn_ev_to_pdu</key>
<param><key>id</key><value>gwn_ev_to_pdu_0_0</value></param>
<param><key>in_type</key><value>'payload'</value></param>
</block>
<block>
<key>gwn_event_constructor</key>
<param><key>id</key><value>gwn_event_constructor_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>dst_address</key><value>'Bubu'</value></param>
<param><key>Destination</key><value>False</value></param>
<param><key>seq_nr</key><value>1</value></param>
<param><key>src_address</key><value>'Marten'</value></param>
</block>
<block>
<key>gwn_event_constructor</key>
<param><key>id</key><value>gwn_event_constructor_0_0</value></param>
<param><key>debug</key><value>debug_rx</value></param>
<param><key>dst_address</key><value>'Marten'</value></param>
<param><key>Destination</key><value>False</value></param>
<param><key>seq_nr</key><value>1</value></param>
<param><key>src_address</key><value>'Bubu'</value></param>
</block>
<block>
<key>gwn_event_guider</key>
<param><key>id</key><value>gwn_event_guider_0</value></param>
<param><key>type_2</key><value>'CtrlACK'</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>type_1</key><value>'DataData'</value></param>
<param><key>my_address</key><value>'Marten'</value></param>
</block>
<block>
<key>gwn_event_guider</key>
<param><key>id</key><value>gwn_event_guider_0_0</value></param>
<param><key>type_2</key><value>'CtrlACK'</value></param>
<param><key>debug</key><value>debug_rx</value></param>
<param><key>type_1</key><value>'DataData'</value></param>
<param><key>my_address</key><value>'Bubu'</value></param>
</block>
<block>
<key>gwn_pdu_to_ev</key>
<param><key>id</key><value>gwn_pdu_to_ev_0</value></param>
<param><key>in_type</key><value>'payload'</value></param>
</block>
<block>
<key>gwn_pdu_to_ev</key>
<param><key>id</key><value>gwn_pdu_to_ev_0_0</value></param>
<param><key>in_type</key><value>'payload'</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio import digital</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import gwnutils</value></param>
</block>
<block>
<key>gwn_virtual_channel</key>
<param><key>id</key><value>llegada8</value></param>
<param><key>prob_loss</key><value> 0.5</value></param>
</block>
<block>
<key>gwn_virtual_channel</key>
<param><key>id</key><value>llegada_7</value></param>
<param><key>prob_loss</key><value> 0.</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>analog_probe_avg_mag_sqrd_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_1</source_block_id><sink_block_id>gwn_pdu_to_ev_0</sink_block_id><source_key>pdus</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_1_0</source_block_id><sink_block_id>gwn_pdu_to_ev_0_0</sink_block_id><source_key>pdus</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>gwn_CSMA_FSM_0</source_block_id><sink_block_id>llegada8</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_CSMA_FSM_0</source_block_id><sink_block_id>gwn_ev_to_pdu_0</sink_block_id><source_key>out1</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_CSMA_FSM_0_0</source_block_id><sink_block_id>llegada_7</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_CSMA_FSM_0_0</source_block_id><sink_block_id>gwn_ev_to_pdu_0_0</sink_block_id><source_key>out1</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_ack_rx_0</source_block_id><sink_block_id>gwn_ev_to_pdu_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_ack_rx_0</source_block_id><sink_block_id>llegada8</sink_block_id><source_key>out1</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_ack_rx_0_0</source_block_id><sink_block_id>gwn_ev_to_pdu_0_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_ack_rx_0_0</source_block_id><sink_block_id>llegada_7</sink_block_id><source_key>out1</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_ev_to_pdu_0</source_block_id><sink_block_id>blocks_socket_pdu_1</sink_block_id><source_key>pdu</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gwn_ev_to_pdu_0_0</source_block_id><sink_block_id>blocks_socket_pdu_1_0</sink_block_id><source_key>pdu</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gwn_event_constructor_0</source_block_id><sink_block_id>gwn_CSMA_FSM_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_event_constructor_0_0</source_block_id><sink_block_id>gwn_CSMA_FSM_0_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_event_guider_0</source_block_id><sink_block_id>gwn_ack_rx_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_event_guider_0</source_block_id><sink_block_id>gwn_CSMA_FSM_0</sink_block_id><source_key>out1</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_event_guider_0_0</source_block_id><sink_block_id>gwn_ack_rx_0_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_event_guider_0_0</source_block_id><sink_block_id>gwn_CSMA_FSM_0_0</sink_block_id><source_key>out1</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_pdu_to_ev_0</source_block_id><sink_block_id>gwn_event_constructor_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_pdu_to_ev_0_0</source_block_id><sink_block_id>gwn_event_constructor_0_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>llegada8</source_block_id><sink_block_id>gwn_event_guider_0_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>llegada_7</source_block_id><sink_block_id>gwn_event_guider_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
</flow_graph>
